# Repository syamei0/kicad

File README.md:

power_suplly_v3.1.0

⚠注意⚠　　
リレーの逆起電力対策がされていません。　　
ダイオードを外付けして使用してください。　　

入力は12V  
出力  
12V×7(合計20Aまで)  
5V×8(3.3V出力と合わせて合計1.5Aまで)  
3.3V×8(合計800mAまで)  

LEDの抵抗値変えたら24V入力もできるかも  
その場合12V系統は無くなるけど　　

左下のDIPスイッチで非常停止ボタン押したときに切る系統を変更可能  

パーツ
https://partscabi.net/list/3c4d911b-a046-48f9-8f62-2c7ad6c0e181

ESP32_SMD_v2.1.0  
esp32-wroom-32e用の基板です。

仕様　　  
・圧電スピーカーは0ピン　  
・CANはTXDが5ピン、RXDが4ピン　　  
・JP3とJP4はcanの終端抵抗　　  
・上バー付の数字はPWM可　　  
・白抜き文字は書き込み中プルアップ　　  

パーツ(コンデンサー類未入力)
https://partscabi.net/list/7565f6eb-4755-48bc-bd06-0c08493c0ea4

## KiCad design ESP32_SMD/ESP32_SMD.kicad_pcb

Parts:
C1, C2, C3, C6: 0.1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 2.2μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 0.33μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 22μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: MF-R050
J1: POWER(5V); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2, J5, J6, J7, J8, J11, J12, J13, J14, J21: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: FT234X; PinHeader_1x04_P2.54mm_Vertical
J4, J17: I2C; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: INPUT_1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: INPUT_2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J15, J18, J19, J22, J23, J24: Conn_01x03_Socket; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J16, J20: Conn_01x15_Socket; PinSocket_1x15_P2.54mm_Vertical
J25, J27: RJ45_Shielded; RJ45
J26: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
JP3, JP4: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
LS1: PKM13EPYH4000-A0
Q1, Q2: 2SC2712; SOT-23
R1, R30: 240Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R35, R36: 10kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33, R34: 5.1kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R37: 120Ω; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Nidec_CAS-120A1; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
SW2: BOOT; DTS-63-N-V
SW3: EN; DTS-63-N-V
U1: ESP32-WROOM-32E
U2: NJM2845DL1-33; TO-252-3_TabPin2
U4: ATA6561; SOP-8_3.9x4.9mm_P1.27mm
U5: CH340K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm

Connections:
+3.3V: C3.2, C4.2, C6.1, C9.2, J16.14, R1.1, R2.1, U1.2 (VDD), U2.3 (OUT), U4.8 (VIO), U5.7 (VCC), U5.10 (V3)
+5V: C5.2, C7.2, C8.2, F1.2, J20.15, U2.1 (IN), U4.3 (VCC)
+5V_PC: J3.1 (5V), J26.A4 (VBUS), J26.A9 (VBUS), J26.B4 (VBUS), J26.B9 (VBUS), SW1.3 (A)
EN: C1.1, J16.13, Q1.1 (C), R2.2, R3.2, SW3.2 (B), U1.3 (EN)
GND: C1.2, C2.2, C3.1, C4.1, C5.1, C6.2, C7.1, C8.1, C9.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), J1.2, J3.2 (GND), J15.1, J16.15, J22.1, J23.1, J24.1, J25.SH, J26.A1 (GND), J26.A12 (GND), J26.B1 (GND), J26.B12 (GND), J26.S1 (SHIELD), J27.SH, LS1.1, R33.2, R34.2, SW2.1 (A), SW3.1 (A), U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (GND), U4.2 (GND), U4.5 (STBY), U5.3 (GND), U5.11 (GND)
IO0: C2.1, J20.12, J21.2, Q2.1 (C), R18.2, R30.2, SW2.2 (B), U1.25 (IO0)
IO2: J5.1, J20.13, J24.2, R17.2, U1.24 (IO2)
IO4: J13.1, J20.11, R19.2, U1.26 (IO4), U4.4 (RXD)
IO5: J13.2, J18.1, J20.8, R22.2, U1.29 (IO5), U4.1 (TXD)
IO12: J6.1, J16.2, J23.2, R14.2, U1.14 (IO12)
IO13: J5.2, J16.1, J24.3, R15.2, U1.16 (IO13)
IO14: J11.2, J16.3, R13.2, U1.13 (IO14)
IO15: J11.1, J20.14, R16.2, U1.23 (IO15)
IO16: J14.2, J18.3, J20.10, R20.2, U1.27 (IO16)
IO17: J14.1, J18.2, J20.9, R21.2, U1.28 (IO17)
IO18: J19.3, J20.7, J21.1, R23.2, U1.30 (IO18)
IO19: J12.2, J19.2, J20.6, R24.2, U1.31 (IO19)
IO21: J4.1, J17.1, J20.5, R25.2, U1.33 (IO21)
IO22: J4.2, J17.2, J20.2, R28.2, U1.36 (IO22)
IO23: J12.1, J19.1, J20.1, R29.2, U1.37 (IO23)
IO25: J7.2, J16.6, J22.2, R10.2, U1.10 (IO25)
IO26: J7.1, J16.5, J22.3, R11.2, U1.11 (IO26)
IO27: J6.2, J16.4, J23.3, R12.2, U1.12 (IO27)
IO32: J8.2, J15.3, J16.8, R8.2, U1.8 (IO32)
IO33: J8.1, J15.2, J16.7, R9.2, U1.9 (IO33)
IO34: J9.2, J16.10, R6.2, U1.6 (IO34)
IO35: J9.1, J16.9, R7.2, U1.7 (IO35)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R16.1
unnamed: D3.2 (A), R17.1
unnamed: D4.2 (A), R18.1
unnamed: D5.2 (A), R19.1
unnamed: D6.2 (A), R20.1
unnamed: D7.2 (A), R21.1
unnamed: D8.2 (A), R3.1
unnamed: D9.2 (A), R4.1
unnamed: D10.2 (A), R5.1
unnamed: D11.2 (A), R6.1
unnamed: D12.2 (A), R7.1
unnamed: D13.2 (A), R8.1
unnamed: D14.2 (A), R9.1
unnamed: D15.2 (A), R10.1
unnamed: D16.2 (A), R11.1
unnamed: D17.2 (A), R12.1
unnamed: D18.2 (A), R13.1
unnamed: D19.2 (A), R14.1
unnamed: D20.2 (A), R15.1
unnamed: D21.2 (A), R22.1
unnamed: D22.2 (A), R23.1
unnamed: D23.2 (A), R24.1
unnamed: D24.2 (A), R25.1
unnamed: D25.2 (A), R26.1
unnamed: D26.2 (A), R27.1
unnamed: D27.2 (A), R28.1
unnamed: D28.2 (A), R29.1
unnamed: J1.1, SW1.1 (C)
unnamed: J26.A5 (CC1), R33.1
unnamed: J26.B5 (CC2), R34.1
unnamed: JP3.1 (A), R37.2
unnamed: J25.1, J27.1, JP3.2 (B), U4.6 (CANH)
unnamed: J25.2, J27.2, JP4.1 (A), U4.7 (CANL)
unnamed: JP4.2 (B), R37.1
unnamed: LS1.2, R30.1
unnamed: Q1.2 (B), R36.2
unnamed: Q1.3 (E), R35.1, U5.6 (~RTS)
unnamed: Q2.2 (B), R35.2
unnamed: Q2.3 (E), R36.1, U5.4 (~DTR)
unnamed: F1.1, SW1.2 (B)
unnamed: J26.A6 (D+), J26.B6 (D+), U5.1 (UD+)
unnamed: J26.A7 (D-), J26.B7 (D-), U5.2 (UD-)
RXD0/IO3: J2.2, J3.3 (TxD), J20.4, R26.2, U1.34 (RXD0/IO3), U5.8 (TXD)
SENSOR_VN: J10.1, J16.11, R5.2, U1.5 (SENSOR_VN)
SENSOR_VP: J10.2, J16.12, R4.2, U1.4 (SENSOR_VP)
TXD0/IO1: J2.1, J3.4 (RxD), J20.3, R27.2, U1.35 (TXD0/IO1), U5.9 (RXD)

Notes on the sheet:
PWM
確認用LED

Board: 2 copper layers, 95.0 x 72.0 mm, 112 parts (0 on the bottom side), 74 nets.

File ESP32_SMD/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C6",0603,4,0.1μF,
C4,0603,1,2.2μF,
C5,0603,1,0.33μF,
C7,0603,1,22μF,
"C8, C9",0603,2,100nF,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D3, D4, D5, D6, D7, D8, D9",0603,28,LED,
F1,MF-R050,1,MF-R050,
J1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,POWER(5V),
J10,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,INPUT_2,
"J11, J12, J13, J14, J2, J21, J5, J6, J7, J8",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,10,Conn_01x02_Socket,
"J15, J18, J19, J22, J23, J24",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,6,Conn_01x03_Socket,
"J16, J20",PinSocket_1x15_P2.54mm_Vertical,2,Conn_01x15_Socket,
"J17, J4",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,2,I2C,
"J25, J27",RJ45_Amphenol_RJHSE5380,2,RJ45_Shielded,
J26,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,USB_C_Receptacle_USB2.0_16P,
J3,PinHeader_1x04_P2.54mm_Vertical,1,FT234X,
J9,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,INPUT_1,
"JP3, JP4",PinHeader_1x02_P2.54mm_Vertical,2,Jumper_2_Open,
LS1,PKM13EPYH4000-A0,1,PKM13EPYH4000-A0,
"Q1, Q2",SOT-23,2,2SC2712,
"R1, R30",0603,2,240Ω,
"R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R3, R35, R36, R4, R5, R6, R7, R8, R9",0603,30,10kΩ,
"R33, R34",0603,2,5.1kΩ,
R37,0603,1,120Ω,
SW1,TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal,1,SW_Nidec_CAS-120A1,
SW2,DTS-63-N-V,1,BOOT,
SW3,DTS-63-N-V,1,EN,
U1,ESP32-WROOM-32E,1,ESP32-WROOM-32E,
U2,TO-252-3_TabPin2,1,NJM2845DL1-33,
U3,MSOP-10_3x3mm_P0.5mm,1,CH340E,
U4,SOP-8_3.9x4.9mm_P1.27mm,1,ATA6561,

## KiCad design power_supply/power_supply.kicad_pcb

Parts:
C1: C_Polarized; CP_Radial_D10.0mm_P5.00mm
C5, C7: 1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C8: 0.1μF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: OSHR1608C1A; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5, D9, D10: GS1010FL; D_SOD-123F
D6, D7, D8: D; D_SOD-123F
F1, F2, F3, F4, F5, F6, F7: Fuse; 3557-15_KEY
J1: XT60_IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J2: Emergency Stop Switch; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3, J4, J5, J6, J7, J8, J25: XT60_OUT; AMASS_XT60-F_1x02_P7.20mm_Vertical
J9, J10, J11, J12, J13, J14, J15, J16: XH_OUT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J17, J18, J19, J20, J21, J22, J23, J24: XH_3.3V_OUT; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
Q1: TTC014; TO-252-3_TabPin2
R1, R2, R3, R4, R6: 10kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 1kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_DIP_x04; KSD42
U1: NJM7805SDL1; TO-252-3_TabPin2
U2: NJM2845DL1-33; TO-252-3_TabPin2
U3: 953-1C-12DG-1
U4, U5: 134-1C-12DS

Connections:
+3.3V_IN: C8.1, U2.3 (OUT), U5.2
+3.3V_OUT: J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J24.1, R3.2, U5.3
+5V_IN: C6.1, C7.1, U1.3 (OUT), U2.1 (IN), U4.2
+5V_OUT: J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, R2.2, U4.3
+12V_IN: C5.1, D4.2 (A), D5.1 (K), J1.2, J2.2, SW1.1, SW1.2, SW1.3, SW1.4, U1.1 (IN), U3.1 (VCC), U3.3 (COM)
+12V_OUT: C1.1, F1.1, F2.1, F3.1, F4.1, F5.2, F6.2, F7.2, JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), JP7.1 (A), R1.2, U3.4 (N.O.)
GND: C1.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), D3.1 (K), D9.2 (A), D10.2 (A), J1.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.2, J10.2, J11.2, J12.2, J13.2, J14.2, J15.2, J16.2, J17.2, J18.2, J19.2, J20.2, J21.2, J22.2, J23.2, J24.2, J25.1, Q1.3 (E), R6.1, U1.2 (GND), U2.2 (GND), U4.4, U5.4
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.2 (A), Q1.2 (C), R4.2, U3.2 (SIG)
unnamed: D6.2 (A), D7.2 (A), D8.2 (A), J2.1
unnamed: D6.1 (K), R5.1, SW1.8
unnamed: D7.1 (K), D9.1 (K), SW1.7, U4.1
unnamed: D8.1 (K), D10.1 (K), SW1.6, U5.1
unnamed: Q1.1 (B), R5.2, R6.2
XT_OUT_1: F1.2, J3.2, JP1.2 (B)
XT_OUT_2: F2.2, J4.2, JP2.2 (B)
XT_OUT_3: F3.2, J5.2, JP3.2 (B)
XT_OUT_4: F4.2, J6.2, JP4.2 (B)
XT_OUT_5: F5.1, J7.2, JP5.2 (B)
XT_OUT_6: F6.1, J8.2, JP6.2 (B)
XT_OUT_7: F7.1, J25.2, JP7.2 (B)

Board: 2 copper layers, 95.0 x 72.0 mm, 67 parts (7 on the bottom side), 24 nets.

File power_supply/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_Radial_D10.0mm_P5.00mm,1,C_Polarized,
"C5, C7",0603,2,1μF,
"C6, C8",0603,2,0.1μF,
"D1, D2, D3",0603,3,LED,
D4,0603,1,OSHR1608C1A,
D5,D_SOD-123F,1,GS1010FL,
"D6, D7, D8",D_SOD-123F,3,D,
"F1, F2, F3, F4, F5, F6, F7",3557-15_KEY,7,Fuse,
J1,AMASS_XT60-M_1x02_P7.20mm_Vertical,1,XT60_IN,
"J10, J11, J12, J13, J14, J15, J16, J9",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,8,XH_OUT,
"J17, J18, J19, J20, J21, J22, J23, J24",JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,8,XH_3.3V_OUT,
J2,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Emergency Stop Switch,
"J25, J3, J4, J5, J6, J7, J8",AMASS_XT60-F_1x02_P7.20mm_Vertical,7,XT60_OUT,
Q1,TO-252-3_TabPin2,1,TTC014,
"R1, R2, R3, R4, R6",0603,5,10kΩ,
R5,0603,1,1kΩ,
SW1,KSD42,1,SW_DIP_x04,
U1,TO-252-3_TabPin2,1,NJM7805SDL1,
U2,TO-252-3_TabPin2,1,NJM2845DL1-33,
U3,953-1C-12DG-1,1,953-1C-12DG-1,
"U4, U5",134-1C-12DS,2,134-1C-12DS,

## KiCad design STM32/STM32/STM32.kicad_pcb

Parts:
J1: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J2, J3, J4, J5, J6, J7, J9, J10, J11, J12, J13, J14, J15, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28: Conn_01x02_Socket; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J8, J16, J33, J34: Conn_01x01_Socket; JST_XH_B1B-XH-AM_1x01_P2.50mm_Vertical
J29: Conn_01x04_Socket; JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical
SW1: SW_DPDT_x2; PinHeader_1x03_P2.54mm_Vertical
U1: NUCLEO-F446RE; MODULE_NUCLEO-F446RE; PARTREV 13

Connections:
GND: J27.1, U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND__1), U1.CN7_20 (CN7_GND__2), U1.CN7_22 (CN7_GND__3), U1.CN10_9 (CN5_GND_1), U1.CN10_20 (CN5_GND_2), U1.CN10_32 (CN9_AGND_1)
unnamed: J1.1, J2.2, U1.CN7_28 (PA0)
unnamed: J1.2, J2.1, U1.CN7_30 (PA1)
unnamed: J1.3, J3.2, U1.CN10_35 (PA2)
unnamed: J1.4, J3.1, U1.CN10_37 (PA3)
unnamed: J1.5, J4.2, U1.CN7_32 (PA4)
unnamed: J1.6, J4.1, U1.CN10_11 (PA5)
unnamed: J1.7, J5.2, U1.CN10_13 (PA6)
unnamed: J1.8, J5.1, U1.CN10_15 (PA7)
unnamed: J1.9, J6.2, U1.CN10_23 (PA8)
unnamed: J1.10, J6.1, U1.CN10_21 (PA9)
unnamed: J1.11, J7.2, U1.CN10_33 (PA10)
unnamed: J1.12, J7.1, U1.CN10_14 (PA11)
unnamed: J1.13, J9.1, U1.CN7_13 (PA13)
unnamed: J1.14, J9.2, U1.CN10_12 (PA12)
unnamed: J8.1, U1.CN7_4 (PD2)
unnamed: J10.1, U1.CN7_17 (PA15)
unnamed: J10.2, U1.CN7_15 (PA14)
unnamed: J11.1, U1.CN7_34 (PB0)
unnamed: J11.2, U1.CN10_24 (PB1)
unnamed: J12.1, U1.CN10_22 (PB2)
unnamed: J12.2, U1.CN10_31 (PB3)
unnamed: J13.1, U1.CN10_27 (PB4)
unnamed: J13.2, U1.CN10_29 (PB5)
unnamed: J14.1, U1.CN10_17 (PB6)
unnamed: J14.2, U1.CN7_21 (PB7)
unnamed: J15.1, U1.CN10_3 (PB8)
unnamed: J15.2, U1.CN10_5 (PB9)
unnamed: J16.1, U1.CN7_6 (E5V)
unnamed: J17.1, U1.CN10_16 (PB12)
unnamed: J17.2, U1.CN10_30 (PB13)
unnamed: J18.1, U1.CN10_28 (PB14)
unnamed: J18.2, U1.CN10_26 (PB15)
unnamed: J19.1, U1.CN7_38 (PC0/PB8)
unnamed: J19.2, U1.CN7_36 (PC1/PB9)
unnamed: J20.1, U1.CN7_35 (PC2)
unnamed: J20.2, U1.CN7_37 (PC3)
unnamed: J21.1, U1.CN10_34 (PC4)
unnamed: J21.2, U1.CN10_6 (PC5)
unnamed: J22.1, U1.CN10_4 (PC6)
unnamed: J22.2, U1.CN10_19 (PC7)
unnamed: J23.1, U1.CN10_2 (PC8)
unnamed: J23.2, U1.CN10_1 (PC9)
unnamed: J24.1, U1.CN7_1 (PC10)
unnamed: J24.2, U1.CN7_2 (PC11)
unnamed: J25.1, U1.CN7_3 (PC12)
unnamed: J25.2, U1.CN7_23 (PC13)
unnamed: J26.1, U1.CN7_25 (PC14)
unnamed: J26.2, U1.CN7_27 (PC15)
unnamed: J27.2, SW1.2 (B)
unnamed: J28.1, U1.CN7_31 (PH1)
unnamed: J28.2, U1.CN7_29 (PH0)
unnamed: J29.1, U1.CN7_33 (VBAT)
unnamed: J29.2, U1.CN7_14 (CN7_RESET)
unnamed: J29.3, U1.CN7_12 (CN7_IOREF)
unnamed: J29.4, U1.CN7_7 (BOOT0)
unnamed: J33.1, U1.CN10_7 (AVDD)
unnamed: J34.1, U1.CN10_8 (U5V)
unnamed: SW1.1 (A), U1.CN7_5 (VDD)

Board: 2 copper layers, 100.0 x 100.0 mm, 33 parts (0 on the bottom side), 59 nets.
